options:
  parameters:
    author: Jacob McSwain
    copyright: 2026 Jacob McSwain, GPL-3.0-or-later
    description: Decode a DMR recording of 8-bit I/Q (rtl_sdr) with the dmrgo receiver
    generate_options: no_gui
    id: dmrgo_rx_file
    output_language: python
    run_options: run
    title: dmrgo RX from a file
  states: {}

blocks:
- name: samp_rate
  id: parameter
  parameters:
    comment: Sample rate of the recording. The resampler makes 48 kHz of it.
    label: Sample Rate
    short_id: r
    type: intx
    value: '256000'
  states: {}
- name: recording
  id: parameter
  parameters:
    label: Recording
    short_id: i
    type: str
    value: ../../v2/cmd/dmrrf/testdata/xpr8400_bs_voice_weak.cu8
  states: {}
- name: audio_file
  id: parameter
  parameters:
    label: Audio WAV File
    short_id: o
    type: str
    value: dmrgo_audio.wav
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: recording
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-127.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/128
    type: float
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: Resample to the 48 kHz of the receiver.
    decim: samp_rate // math.gcd(samp_rate, 48000)
    interp: 48000 // math.gcd(samp_rate, 48000)
    type: ccc
  states: {}
- name: dmrgo_rx_0
  id: dmrgo_rx
  parameters:
    ambe_lib: ''
    audio_slot: '0'
    codec2_mode: '2400'
    input_type: complex
    lib_path: ''
    samp_rate: '48000'
    tier: '2'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: audio_file
    format: FORMAT_WAV
    samp_rate: '8000'
  states: {}
- name: import_math
  id: import
  parameters:
    imports: import math
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_deinterleave_0, '0', blocks_float_to_complex_0, '0']
- [blocks_deinterleave_0, '1', blocks_float_to_complex_0, '1']
- [blocks_file_source_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_float_to_complex_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_deinterleave_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [dmrgo_rx_0, '0', blocks_wavfile_sink_0, '0']
- [dmrgo_rx_0, bursts, blocks_message_debug_0, print_pdu]
- [rational_resampler_xxx_0, '0', dmrgo_rx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
